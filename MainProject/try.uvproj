# Keil uVision project try.uvproj, settings and files
target Target 1 (MCS-51)
  device: C8051F020 Silicon Labs
  cpu: IRAM(0-0xFF) XRAM(0-0xFFF) IROM(0-0xFFFF) CLOCK(25000000)
  output: final +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: C8051F020.h DIO.c DIO.h Keypad.c Keypad.h main.c std_macros.h SevenSegments.c SevenSegments.h stepper.c stepper.h
